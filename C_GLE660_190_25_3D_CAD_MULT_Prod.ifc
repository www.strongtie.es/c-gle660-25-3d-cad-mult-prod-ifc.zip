Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:13:41
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:13:41 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{15FCADCA-A535-40C9-AF7A-7759E46C77AB}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:13:41 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:13:41 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:13:41 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE660_190_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GLE660_190_25, GLE660_190_25:GLE660_190_25:171611
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.005181 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE660/190/2.5
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.075; Reference: GLE660/190/2.5
Materials and Finishes - Product Material: Galvanised
Identity Data - OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; Description: Joist hanger; UniClass Title: Joist hangers; Product Type: Joist hanger; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Name: GLE660/190/2.5; Model: GLE660/190/2.5; ObjectType: GLE660/190/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; Model ID: 0282879506527827193030068073691259956265; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com
