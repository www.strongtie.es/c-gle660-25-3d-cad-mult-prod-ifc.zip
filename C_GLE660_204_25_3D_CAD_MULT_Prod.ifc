Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:13:46
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:13:46 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CE0505AF-53FD-43BD-9CF0-C9487E283C4C}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:13:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:13:46 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:13:46 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE660_204_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GLE660_204_25, GLE660_204_25:GLE660_204_25:176007
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.005181 ft3
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE660/204/2.5
Identity Data - Manufacturer: Simpson Strong-Tie; ObjectType: GLE660/204/2.5; URL: www.strongtie.eu; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; Product Type: Joist hanger; Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; Model ID: 0282879506527827193030068073691259956265; Model: GLE660/204/2.5; Name: GLE660/204/2.5; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE660/204/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.075; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
